Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: GD8_SU.IFC
Time: 2022-11-24T05:52:43
Written by: SwIFC
Made in: SolidWorks 2015

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: C28_BOT
In: Default Storey
PSet_Mass_Property - Mass Measure: 2.74059; Area Measure: 1.29361 m2; Volume Measure: 0.00274059 m3
